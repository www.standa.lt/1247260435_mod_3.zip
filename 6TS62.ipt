# Autodesk Inventor part: 6TS62
## iProperties
Created: 2008-09
Part Number: 6TS62
Document SubType Name: Modeling
Designer: Darius
Author: Darius
## Feature names
1. Base1
